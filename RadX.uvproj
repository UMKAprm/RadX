# Keil uVision project RadX.uvproj, settings and files
target RadX (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RadX
  c flags: Optim=1 uC99=1
  c include: .\CMSIS;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;..\RadX;.\config;.\User\Inc;.\User\Src;.\Startup
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Startup/: startup_stm32f10x_md_vl.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group StdPerph
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_dac.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
  group User
    ./User/Src/: LCD_Nokia1202.c main.c InitAll.c Time.c ADC.c UI.c
  group config
    ./config/: stm32f10x.h stm32f10x_conf.h
